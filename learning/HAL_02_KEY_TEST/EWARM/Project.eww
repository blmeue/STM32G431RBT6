<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\HAL_02_KEY_TEST.ewp</path>
  </project>
  <batchBuild />
</workspace>
